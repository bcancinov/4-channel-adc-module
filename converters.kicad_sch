File: converters.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: edit README.md
Other:
- company: (none) -> NOIRLab
- title: (none) -> 4 channel ADC Module
